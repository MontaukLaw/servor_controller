# Keil uVision project atk_g474.uvprojx, settings and files
target STEER (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32G474VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: atk_g474 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G474xx
  c include: ..\..\User;..\..\Drivers;..\..\Drivers\CMSIS\Device\ST\STM32G4xx\Include;..\..\Drivers\CMSIS\Include;..\..\Drivers\STM32G4xx_HAL_Driver\Inc;..\..\Middlewares
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32G4xx/Source/Templates/arm/: startup_stm32g474xx.s
  group User
    ../../User/: main.c stm32g4xx_it.c
    ../../Drivers/CMSIS/Device/ST/STM32G4xx/Source/Templates/: system_stm32g4xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32G4xx_HAL_Driver
    ../../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dma.c stm32g4xx_hal_gpio.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_usart.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_usart_ex.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c
  group Driverss/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/TIMER/: atim.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/LCD/: lcd.c
    ../../Drivers/BSP/SPI/: spi.c
    ../../Drivers/BSP/STEERING_ENGINE/: steering_engine.c
  group Readme
    ../../: readme.txt
